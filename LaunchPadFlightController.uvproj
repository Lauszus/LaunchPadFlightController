# Keil uVision project LaunchPadFlightController.uvproj, settings and files
target TM4C123GH6PM (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: LaunchPadFlightController
  c flags: Optim=1
  c define: rvmdk PART_TM4C123GH6PM UART_BUFFERED
  c misc: --c99
  c include: .\lib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group src
    ./src/: main.c startup_rvmdk.S RX.c UART.c time.c ppm.c MPU6500.c KalmanX.c KalmanY.c PID.c
    ./lib/utils/: uartstdio.c
    ./lib/driverlib/rvmdk/: driverlib.lib
